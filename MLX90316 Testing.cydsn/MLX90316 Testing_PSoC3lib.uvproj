# Keil uVision project MLX90316 Testing_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: MLX90316 Testing_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h MLX90316_SCLK.c MLX90316_SCLK.h MLX90316_SCLK_aliases.h MLX90316_SPIM.c MLX90316_SPIM.h MLX90316_SPIM_PM.c MLX90316_SPIM_INT.c MLX90316_SPIM_PVT.h MLX90316_SS.c MLX90316_SS.h MLX90316_SS_aliases.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h MLX90316_SS_ControlReg.h MLX90316_SS_ControlReg.c MLX90316_SS_ControlReg_PM.c LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h SPIM_Clock.c SPIM_Clock.h MLX90316_MOSI_DEBUG.c MLX90316_MOSI_DEBUG.h MLX90316_MOSI_DEBUG_aliases.h MLX90316_MISO.c MLX90316_MISO.h MLX90316_MISO_aliases.h MLX90316_MISO_Comp.c MLX90316_MISO_Comp.h MLX90316_MISO_Comp_PM.c MLX90316_VDAC8.c MLX90316_VDAC8.h MLX90316_VDAC8_PM.c LCD_CustChars.c
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: MLX90316 Testing_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
